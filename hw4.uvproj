# Keil uVision project hw4.uvproj, settings and files
target Target 1 (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: hw4
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ir_tx.a51
